/********************************文件说明*************************************
*文件名: queue.c

*作者: Yuchen Tan

*版本: V1.0.0

*功能简介: 队列数据结构

*备注:
*1.队列创建基于堆,建议配置: sizeof(HEAP) >= 2Kbyte

*修改履历:

*****************************************************************************/

/*****************************文件包含(私有)**********************************
*
*备注: 无
*
*****************************************************************************/
#include "queue.h"
/*****************************宏定义(私有)************************************
*
*备注: 本文件中,不希望被外部使用或随意修改的宏在这里定义
*
*****************************************************************************/
/*队列参数*/
#define QUEUE_NODE_NB_MAX       (10)
#define QUEUE_NODE_SIZE_MAX     (50)
/**************************数据类型及结构定义(私有)***************************
*
*备注: 本文件中,不希望被外部使用的数据结构及类型在这里定义
*
*****************************************************************************/

/*****************************函数声明(私有)**********************************
*
*备注: 本文件中,不希望被外部调用的函数统一在这里声明
*
*****************************************************************************/

/********************************变量定义*************************************
*
*备注: 不要在.h中定义变量,防止多个.c包含这个.h,导致编译后报错变量重复定义
*
*****************************************************************************/

/********************************函数定义************************************
*函数名:

*函数功能描述: 队列数据结构操作

*函数参数: 无

*函数返回值: 无

*备注:
*****************************************************************************/
/*队列操作-初始化队列*/
void queue_Init(QUEUE_t *Queue)
{
    Queue->NodeNb = 0;
    Queue->Head = Queue->Rear = 0;
    Queue->PushNb = 0;
    Queue->PopNb = 0;
}
/*队列操作-创建队列*/
int8_t queue_Create(QUEUE_t **pQueue)
{
    QUEUE_t *NewQueue = (QUEUE_t *)malloc(sizeof(QUEUE_t));
    if(!NewQueue)
        return QOP_ERR_MALLOC;
    queue_Init(NewQueue);
    *pQueue = NewQueue; //传出参数
    return QOP_SUCCESS;
}
/*队列操作-销毁队列*/
int8_t queue_Destroy(QUEUE_t **pQueue)
{
    QUEUE_t *Queue = *pQueue;

    if(!Queue)
        return QOP_ERR_DATA;
    while(!queue_Empty(Queue))
    {
        queue_Pop(Queue, 0, 0);
    }
    free(Queue);
    *pQueue = 0;        //队列句柄清0,防止重复释放
    return QOP_SUCCESS;
}
/*队列操作-队列是否存在*/
BOOL queue_Exist(QUEUE_t *Queue)
{
    return (BOOL)(Queue != 0);
}
/*队列操作-队列空?*/
BOOL queue_Empty(QUEUE_t *Queue)
{
    return (BOOL)(Queue->NodeNb == 0);
}
/*队列操作-队列已满?*/
BOOL queue_Full(QUEUE_t *Queue)
{
    return (BOOL)(Queue->NodeNb == QUEUE_NODE_NB_MAX);
}
/*队列操作-获取节点个数*/
uint8_t queue_Get_Node_Nb(QUEUE_t *Queue)
{
    return Queue->NodeNb;
}
/*队列操作-获取头节点数据*/
uint8_t* queue_Get_HeadNode_Data(QUEUE_t *Queue)
{
    return Queue->Head->Data;
}
/*队列操作-获取头节点数据长度*/
uint8_t queue_Get_HeadNode_DataSize(QUEUE_t *Queue)
{
    return Queue->Head->DataSize;
}
/*队列操作-入队*/
int8_t queue_Push(QUEUE_t *Queue, const uint8_t *Data, uint8_t DataSize)
{
    NODE_t *RearNode = 0;
    if(!Data || !Queue || DataSize > QUEUE_NODE_SIZE_MAX)
        return QOP_ERR_DATA;
    if(queue_Full(Queue))
        return QOP_ERR_FULL;
    /*创建尾节点*/
    RearNode = (NODE_t*)malloc(sizeof(NODE_t) + DataSize);
    if(!RearNode)
        return QOP_ERR_MALLOC;
    /*尾节点数据初始化*/
    RearNode->Next = 0;
    RearNode->DataSize = DataSize;
    for(uint8_t i = 0; i < DataSize; i++)
    {
        RearNode->Data[i] = Data[i];
    }
    /*队列状态更新*/
    if(queue_Empty(Queue))
    {
        Queue->Head = RearNode;
    }else
    {
        Queue->Rear->Next = RearNode;   //节点连接
    }
    Queue->Rear = RearNode;
    Queue->NodeNb++;
    Queue->PushNb++;
    return QOP_SUCCESS;
}
/*队列操作-出队*/
int8_t queue_Pop(QUEUE_t *Queue, uint8_t *Data, uint8_t *DataSize)
{
    NODE_t *HeadNode = 0;
    if(!Queue)
        return QOP_ERR_DATA;
    if(queue_Empty(Queue))
        return QOP_ERR_EMPTY;
    /*读出首节点数据*/
    if(DataSize)
        *DataSize = Queue->Head->DataSize;
    if(Data)
    {
        for(uint8_t i = 0; i < Queue->Head->DataSize; i++)
        {
            Data[i] = Queue->Head->Data[i];
        }
    }
    /*删除首节点*/
    HeadNode = Queue->Head;
    if(HeadNode->Next == 0)
    {   //删除前只剩首节点的情况
        Queue->Head = Queue->Rear = 0;
    }else
    {
        Queue->Head = Queue->Head->Next;    //节点连接断开
    }
    free(HeadNode);
    /*队列状态更新*/
    Queue->NodeNb--;
    Queue->PopNb++;
    return QOP_SUCCESS;
}
/********************************函数定义************************************
*函数名:

*函数功能描述: 队列数据结构操作

*函数参数: 无

*函数返回值: 无

*备注:
*****************************************************************************/
void queue_Test(void)
{
    static int8_t s_TestQueueCmd = 0;
    static QUEUE_t* Q1 = 0;
    static uint8_t ItemData[100] = {0};
//    static uint8_t ItemSize = 0;
//    int8_t Res = 0;
    if(s_TestQueueCmd == -1)
    {
//        Res = sizeof(NODE_t);   //NODE_t结构中的Data[0]不占内存.
        s_TestQueueCmd = 0;
    }
    if(s_TestQueueCmd == 1)
    {
//        Res = queue_Create(&Q1);
        s_TestQueueCmd = 0;
    }
    if(s_TestQueueCmd == 2)
    {
        if(queue_Exist(Q1))
//            Res = queue_Destroy(&Q1);
        s_TestQueueCmd = 0;
    }
    if(s_TestQueueCmd == 3)
    {
        for(uint8_t i = 0; i < 100; i++)
        {
            ItemData[i] += i;
        }
//        Res = queue_Push(Q1, ItemData, 100);
        s_TestQueueCmd = 0;
    }
    if(s_TestQueueCmd == 4)
    {
        memset(ItemData, 0, 100);
//        Res = queue_Pop(Q1, ItemData, &ItemSize);
        s_TestQueueCmd = 0;
    }
}
